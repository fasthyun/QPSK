options:
  parameters:
    author: Barry Duggan, modified by Gary Schafer
    category: Custom
    generate_options: qt_gui
    id: qpsk_stage5_ver3
    output_language: python
    title: QPSK Modulator / Demodulator (modem)
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: 0.35*1
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[13, 128, 91, 197, 195, 54, 124, 185]'
  states: {}
- name: psk8
  id: variable_constellation
  parameters:
    const_points: '[1.00 + 0.00j, 0.71 + 0.71j, 0.00 + 1.00j,  -0.71 + 0.71j, -1.00 + 0.00j, -0.71 -0.71j, -0.00 -1.00j, 0.71 -0.71j]'
    precision: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: 8psk
  states: {state: disabled}
- name: psk8
  id: variable_constellation
  parameters:
    const_points: |-
      [ 0.92387953+0.38268343j,  0.38268343+0.92387953j,
             -0.38268343+0.92387953j, -0.92387953+0.38268343j,
             -0.92387953-0.38268343j, -0.38268343-0.92387953j,
              0.38268343-0.92387953j,  0.92387953-0.38268343j]
    dims: '1'
    precision: '4'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(psk8, False, sps, True, excess_bw, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: var_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 2000-100
    gain: '1.0'
    samp_rate: samp_rate
    width: '80'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: var_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: 0.35*1
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_endian_swap_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: /home/hyun/psk8_8k_16t_1200.pcm (works)
    file: /home/hyun/works/QPSK/test_u2_4.pcm
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 8000*4
    type: complex
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: excess_bw
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-2000'
    decim: '1'
    samp_rate: samp_rate
    taps: var_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: 8k -> 9.6k
    nfilts: '32'
    rrate: 9600/8000
    taps: '[]'
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    grid: 'True'
    gui_hint: 2,0,10,10
    label1: Synced Only
    label2: costas loop
    name: Synced Constellation
    nconnections: '2'
    size: '1024'
    type: complex
    update_time: '0.05'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,10,10
    label1: sybol sync
    name: Synced Constellation
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: 2048*1
    gui_hint: 12,0,10,20
    label1: filtered
    name: Spectrum
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,10,10,10
    label1: Recovered Data
    label2: Original Data
    name: Synchronized QPSK
    size: '100'
    srate: '1'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,20
    label1: '|corr|^2'
    label2: Re{corr}
    label3: Im{corr}
    name: ''
    nconnections: '3'
    size: '80000'
    srate: samp_rate
    tr_level: '100'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '400'
    ymin: '-200'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_signal
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: filtered_signal
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_1, '2']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_endian_swap_0, '0', blocks_short_to_float_0, '0']
- [blocks_file_source_0, '0', blocks_endian_swap_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_corr_est_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_float_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_null_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', digital_corr_est_cc_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
